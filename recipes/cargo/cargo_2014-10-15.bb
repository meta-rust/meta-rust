SRCREV = "9788700351f5c236c4e403f28a9156e6ee0b2483"

# This version doesn't work with rust-0.12.0
DEFAULT_PREFERENCE = "-1"

require recipes/cargo/cargo.inc
