SRCREV = "abc712795321d13dcf6839242c476e42d3e211d2"

# This version doesn't work with rust-0.12.0
DEFAULT_PREFERENCE = "-1"

require recipes/cargo/cargo.inc
