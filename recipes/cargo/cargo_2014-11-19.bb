SRCREV_cargo = "baa873b09a3d54447516954161d91f794b8ec33d"

SRC_URI_append = "\
	file://0001-dl-snapshot-be-more-forgiving-to-triples.patch \
"

require cargo.inc
