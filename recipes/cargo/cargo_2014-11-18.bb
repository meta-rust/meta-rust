SRCREV_cargo = "15227f1447220f8e5c1e5a5ff709aff6663a0787"

SRC_URI_append = "\
	file://0001-dl-snapshot-be-more-forgiving-to-triples.patch \
"

require cargo.inc
