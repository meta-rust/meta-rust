SRCREV = "0881adf3eef5283bdfc006a23ea907b6529b0027"

# This version doesn't work with rust-0.12.0
DEFAULT_PREFERENCE = "-1"
require recipes/cargo/cargo.inc
