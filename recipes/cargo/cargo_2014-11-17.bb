SRCREV_cargo = "36be0451c406b84ae1e3aefa5deb7715e7d42a43"

SRC_URI_append = "\
	file://0001-dl-snapshot-be-more-forgiving-to-triples.patch \
"

require cargo.inc
