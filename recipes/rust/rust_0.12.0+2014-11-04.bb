SRCREV = "1b2ad7831f1745bf4a4709a1fa1772afb47c933c"
require rust-git.inc

# Doesn't build cargo as of 2014-10-28
# Doesn't build cargo 2014-11-01 (603f29d3421d5aa7396dc57f966e8a80e86d5e0d) (latest at the time)
DEFAULT_PREFERENCE = "-1"
