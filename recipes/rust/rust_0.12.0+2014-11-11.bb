SRCREV = "5d29209bda553e4d23a8b499d2ceb8db5c4f8be5"
require rust-git.inc
