SRCREV = "ceeac26de859bd217d8ff576ff291dbd38ff3951"
require rust-git.inc
