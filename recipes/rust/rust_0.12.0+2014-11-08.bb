SRCREV = "f0ca717c643cbef31859e443ee20db4465ac8864"
require rust-git.inc
