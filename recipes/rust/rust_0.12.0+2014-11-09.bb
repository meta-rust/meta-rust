SRCREV = "efc9a441b9f48912166b0ce375efe677edc0e93a"
require rust-git.inc
