
SRCREV = "7b021859a4ea33bb0f5512649a5c9792648e9ad6"

require rust-git.inc
