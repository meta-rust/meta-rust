SRCREV = "51a25c7f96ad0d00836314d705e3f0a477562a2c"
require rust-git.inc

# Doesn't build cargo as of 2014-10-28
# Testing with cargo 2014-11-01 (603f29d3421d5aa7396dc57f966e8a80e86d5e0d)
