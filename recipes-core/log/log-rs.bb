DESCRIPTION = "A Rust library providing a lightweight logging facade"
DEPENDS = "libc-rs"

require log.inc
