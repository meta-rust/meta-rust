DESCRIPTION = "A regular expression parser"

require regex.inc

# Should only be used directly by regex
CRATE_TYPE = "rlib"
LIB_SRC = "${S}/regex-syntax/src/lib.rs"
