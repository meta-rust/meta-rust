require num.inc

DEPENDS += "num-traits"

LIB_SRC = "${S}/integer/src/lib.rs"
