require num.inc

DEPENDS += "\
	num-traits \
	num-integer \
	num-iter \
	"

LIB_SRC = "${S}/src/lib.rs"
