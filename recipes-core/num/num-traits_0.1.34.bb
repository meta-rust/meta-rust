require num.inc

LIB_SRC = "${S}/traits/src/lib.rs"
