require num.inc

DEPENDS += "num-traits"
DEPENDS += "num-integer"

LIB_SRC = "${S}/iter/src/lib.rs"
