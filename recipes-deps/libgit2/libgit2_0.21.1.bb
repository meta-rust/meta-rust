
SRC_URI[md5sum] = "cbf3422d54dd6f55f09855a6eb749f41"
require libgit2.inc
