
SRC_URI[md5sum] = "cbf3422d54dd6f55f09855a6eb749f41"
SRC_URI[sha256sum] = "bc06bc9b5f8449040b8d0f727c83cbd7a4c2243317d33d57c3c548873294845e"
require libgit2-release.inc
