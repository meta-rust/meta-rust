
SRC_URI[md5sum] = "dbf516d18e176bbb131de3efccfee533"
SRC_URI[sha256sum] = "c7f1bf99ed8aeba65a485489869e2a50f022f3cd847df85e192fc99fdd6c8b5e"
require libgit2-release.inc
