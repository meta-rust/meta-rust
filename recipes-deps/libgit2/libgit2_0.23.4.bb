
LIC_FILES_CHKSUM = "file://COPYING;md5=34197a479f637beb9e09e56893f48bc2"

SRC_URI[md5sum] = "ade3b85d759866c03b6188e397b652fa"
SRC_URI[sha256sum] = "20c0a6ee92c0e19207dac6ddc336b4ae4a1c4ddf91be0891e4b6e6ccba16df0b"

require libgit2-release.inc
