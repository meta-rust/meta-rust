require libgit2-git.inc
SRCREV ?= "2a0f67f04cb717a7e57192696d69f91a3d208705"
LIC_FILES_CHKSUM = "file://COPYING;md5=5ddd5fb64b24982b32a490dccccdabc5"
