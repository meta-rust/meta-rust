# check src/llvm-project/llvm/CMakeLists.txt for llvm version in use
#
LLVM_RELEASE = "14.0.6"
require rust-source-${PV}.inc
require rust-llvm.inc
