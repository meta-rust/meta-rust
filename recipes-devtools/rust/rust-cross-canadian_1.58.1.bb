require rust-cross-canadian.inc
require rust-source.inc
require rust-snapshot.inc

FILESEXTRAPATHS_prepend := "${THISDIR}/rust:"

