# check src/llvm-project/llvm/CMakeLists.txt for llvm version in use
#
LLVM_RELEASE = "15.0.2"
require rust-source-${PV}.inc
require rust-llvm.inc
