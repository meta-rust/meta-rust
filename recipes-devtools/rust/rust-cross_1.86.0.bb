require rust-cross.inc
require rust-source-${PV}.inc

# License file checksum needed for do_populate_lic when including a
# Rust app in an image.
LIC_FILES_CHKSUM="file://LICENSE-APACHE;md5=22a53954e4e0ec258dfce4391e905dac"
