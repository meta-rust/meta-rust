require compiler-rt.inc
require rust-source-${PV}.inc

EXTRA_OECONF = "--disable-rustbuild"
