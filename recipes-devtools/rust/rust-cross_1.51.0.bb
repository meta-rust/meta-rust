require recipes-devtools/rust/rust-cross.inc
require recipes-devtools/rust/rust-source-${PV}.inc
