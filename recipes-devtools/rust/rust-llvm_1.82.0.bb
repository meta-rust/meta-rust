# check src/llvm-project/cmake/modules/LLVMVersion.cmake for llvm version in use
#
LLVM_RELEASE = "19.1.1"
require rust-source-${PV}.inc
require rust-llvm.inc
