# check src/llvm-project/llvm/CMakeLists.txt for llvm version in use
#
LLVM_RELEASE = "16.0.5"
require rust-source-${PV}.inc
require rust-llvm.inc
