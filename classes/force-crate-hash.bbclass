RUSTFLAGS += "-C crate_hash=${BB_TASKHASH}"
